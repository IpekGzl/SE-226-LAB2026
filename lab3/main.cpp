#include <iostream>
using namespace std;

// swap two values using pointers
void swapValues(int* p1, int* p2) {
    int temp = *p1;
    *p1 = *p2;
    *p2 = temp;
}

// print array using pointer notation
void printArray(int* arr, int size) {
    for(int i = 0; i < size; i++) {
        cout << *(arr + i) << " ";
    }
    cout << endl;
}

// find sum of array elements
int findSum(int* arr, int size) {
    int sum = 0;
    for(int i = 0; i < size; i++) {
        sum += *(arr + i);
    }
    return sum;
}

// shift array elements to the right
void shiftRight(int* arr, int size) {
    int last = *(arr + size - 1);


    for(int i = size - 1; i > 0; i--) {
        *(arr + i) = *(arr + i - 1);
    }
    *arr = last;
}

// dynamically create array
int* createArray(int size) {
    int* arr = new int[size];
    return arr;
}

// delete array
void deleteArray(int* arr) {
    delete[] arr;
}

int main() {
    cout << "Creating dynamic array..." << endl;

    int size;
    cout << "Enter array size: ";
    cin >> size;

    int* arr = createArray(size);

    cout << "Enter values: ";
    for(int i = 0; i < size; i++) {
        cin >> *(arr + i);
    }

    cout << "Array elements: " << endl;
    printArray(arr, size);

    cout << "Sum of elements: " << findSum(arr, size) << endl;

    int a = 6, b = 7;
    cout << "Swapping two numbers" << endl;
    cout << "Before swap" << endl;
    cout << "a = " << a << endl;
    cout << "b = " << b << endl;

    swapValues(&a, &b);

    cout << "After swap" << endl;
    cout << "a = " << a << endl;
    cout << "b = " << b << endl;

    cout << "Shifting array to the right..." << endl;
    shiftRight(arr, size);

    cout << "Array after shiftRight:" << endl;
    printArray(arr, size);

    cout << "Deleting array..." << endl;
    deleteArray(arr);
    cout << "Memory released successfully." << endl;

    return 0;
}
